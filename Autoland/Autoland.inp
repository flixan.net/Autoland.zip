FLIGHT VEHICLE INPUT DATA ......
Automatic Landing of Unpowered Vehicle
! In this example we use the longitudinal state-space model of a glider vehicle as it approaches
! on the runway, combine it with the flight control and the guidance systems, and 
! simulate it landing on the runway. The simulation starts when the vehicle is aligned with the 
! runway at an altitude of 9000 ft. Since the vehicle is unpowered, the only controls available 
! in the pitch axis is the elevon and the speed brake aero surfaces.
! The Aileron and Rudder are used in the lateral directions.
!
Body Axes Output,Attitude=Euler Angles,Without GAFD, No Turn Coordination  
 
Vehicle Mass (lb-sec^2/ft), Gravity Accelerat. (g) (ft/sec^2), Earth Radius (Re) (ft)    :   2289.0       32.170      0.20896E+08
Moments and products of Inertias Ixx, Iyy, Izz, Ixy, Ixz, Iyz, in (lb-sec^2-ft)          :  0.16950E+06  0.19788E+07  0.19753E+07   0.0000       131.00       0.0000    
CG location with respect to the Vehicle Reference Point, Xcg, Ycg, Zcg, in (feet)        :  -62.670       0.0000       1.2900    
Vehicle Mach Number, Velocity Vo (ft/sec), Dynamic Pressure (psf), Altitude (feet)       :  0.30000       500.00       210.00       2700.0    
Inertial Acceleration Vo_dot, Sensed Body Axes Accelerations Ax,Ay,Az (ft/sec^2)         :  -5.0000      -4.2200       0.0000      -48.260    
Angles of Attack and Sideslip (deg), alpha, beta rates (deg/sec)                         :   10.500       0.0000       0.0000       0.0000    
Vehicle Attitude Euler Angles, Phi_o,Thet_o,Psi_o (deg), Body Rates Po,Qo,Ro (deg/sec)   :   0.0         -3.5          0.0          0.0000       0.0000       0.0000    
Wind Gust Vel wrt Vehi (Azim & Elev) angles (deg), or Force(lb), Torque(ft-lb), locat:xyz:   Gust         45.0        -3.5    
Surface Reference Area (feet^2), Mean Aerodynamic Chord (ft), Wing Span in (feet)        :   985.00       23.670       49.580    
Aero Moment Reference Center (Xmrc,Ymrc,Zmrc) Location in (ft), {Partial_rho/ Partial_H} :  -61.833       0.0000       1.2920       0.0000    
Aero Force Coef/Deriv (1/deg), Along -X, {Cao,Ca_alf,PCa/PV,PCa/Ph,Ca_alfdot,Ca_q,Ca_bet}:  0.57500E-01 -0.65450E-02   0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeffic/Derivat (1/deg), Along Y, {Cyo,Cy_bet,Cy_r,Cy_alf,Cy_p,Cy_betdot,Cy_V}:   0.0000     -0.28360E-01   0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Force Coeff/Deriv (1/deg), Along Z, {Czo,Cz_alf,Cz_q,Cz_bet,PCz/Ph,Cz_alfdot,PCz/PV}: -0.42036     -0.44543E-01   0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Roll: {Clo, Cl_beta, Cl_betdot, Cl_p, Cl_r, Cl_alfa}:   0.0000     -0.37190E-02   0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeff/Deriv (1/deg), Pitch: {Cmo,Cm_alfa,Cm_alfdot,Cm_bet,Cm_q,PCm/PV,PCm/Ph}: -0.14700E-01 -0.79300E-02   0.0000       0.0000       0.0000       0.0000       0.0000    
Aero Moment Coeffic/Derivat (1/deg), Yaw : {Cno, Cn_beta, Cn_betdot, Cn_p, Cn_r, Cn_alfa}:   0.0000     -0.74000E-03   0.0000       0.0000       0.0000       0.0000    

Number of Control Surfaces, With or No TWD (Tail-Wags-Dog and Hinge Moment Dynamics) ?   :  4   NO TWD  

Control Surface No:  1                                                                     Elevon         
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   10.000       40.000      -30.000       0.0000       0.0000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.000       40.000       2.0000       2.0000       10.000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.0000       0.0000       0.0000       0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -89.700       0.0000      -12.000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:  0.001529      0.0000      -0.01842      0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000     -0.014371      0.0000       0.0000       0.0000       0.0000    
Control Surface No:  2                                                                     Speed Brake    
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   10.000       40.000      -30.000       0.0000       0.0000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.000       40.000       2.0000       2.0000       10.000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.0000       0.0000       0.0000       0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:   0.0000       0.0000       0.0000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:   0.00061      0.0000       0.00082      0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0000      -0.00136      0.0000       0.0000       0.0000       0.0000    
Control Surface No:  3                                                                     Aileron         
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.000        40.000      -40.000       0.0000       0.0000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.000       40.000       2.0000       2.0000       10.000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.0000       0.0000       0.0000       0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -86.200       0.0000       0.000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:   0.0008       0.003        0.0          0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0095       0.0         -0.002        0.0000       0.0000       0.0000    
Control Surface No:  4                                                                     Rudder         
Trim Angle, Max/Min Deflection Angles from Trim, Hinge Line Angles: Phi_h, Lamda_h  (deg):   0.000        40.000      -40.000       90.000       0.0000    
Surface Mass, Inertia about Hinge, Moment Arm (Hinge to Surface CG), Surface Chord, Area :   10.000       40.000       2.0000       2.0000       10.000    
Hinge Moment Derivatives (1/deg), { Chm_Alpha, Chm_Beta, Chm_Delta, Chm_Mach }           :   0.0000       0.0000       0.0000       0.0000    
Location of the Hinge Line Center with respect to Vehicle Reference (feet), {Xcs,Ycs,Zcs}:  -86.100       0.0000       5.000    
Forces (-x,y,z) due to Deflect. and Rates {Ca_del,Cy_del,Cz_del, Ca_deld,Cy_deld,Cz_deld}:   0.0012       0.007        0.0          0.0000       0.0000       0.0000    
Moments due to Deflections and Rates {Cl_del,Cm_del,Cn_del,Cl_deldot,Cm_deldot,Cn_deldot}:   0.0035       0.0         -0.0075       0.0000       0.0000       0.0000    

Number of Thruster Engines, Include or Not the Tail-Wags-Dog and Load-Torque Dynamics ?  :  0   NO TWD  


Number of Gyros, (Attitude and Rate)                                                     :  0

Number of Accelerometers, Along Axis: (x,y,z)                                            :  0

Number of Vane Sensors, (Measuring Alpha or Beta)                                        :  0

Number of Slosh Modes                                                                    :  2
Left Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  202.0  3.6  2.1  0.004  0.008  -70.0  -4.5 -1.0
Rght Tank (slug), Frequ Wy,Wz at 1g (rad/s), Damping (zeta-y-z), Locat {Xsl,Ysl,Zsl} (ft):  202.0  3.6  2.1  0.004  0.008  -70.0   4.5 -1.0

Number of Bending Modes                                                                  :  0
                                                                                                    
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Pitch Axis                                                 
Automatic Landing of Unpowered Vehicle 
! Pitch system is extracted from the coupled system above                                              
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   1   2   5
Extract States :   3   4   7   9  10  11  12  13  14  15  16  17  18
Extract Outputs:   3   4   7   9  10  14
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Pitch Axis-2                                                  
Automatic Landing of Unpowered Vehicle, Pitch Axis                                                  
! Use the above system and replace its outputs with a new set of outputs                                         
NEW SYSTEM OUTPUTS FROM PREVIOUS SYSTEM OUTPUTS/ STATES/ DERIVATIVES
From Old System State :    1                        Pitch Attitude    (theta-rigid)  (radians)                                      
From Old System State :    2                        Pitch Rate        ( q -rigid)    (rad/sec)                                      
From Old System State :    3                        Angle of attack   (alfa-rigid)   (radians)                                      
From Old System State :    4                        Change in Altitude (delta-h)      (feet)                                        
From Old System State :    5                        Change in Velocity (delta-V)      (ft/sec)                                      
From Old System Output:    6                        CG Acceleration along Z axis, (ft/sec^2)                                        
From Output Derivative:    4                        Change in Altitude, delta-h -(dot) (ft/sec)                    
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Pitch Axis-3                                                  
Automatic Landing of Unpowered Vehicle, Pitch Axis                                                  
! Another modified version of the above pitch system that includes 
! Slosh Mass displacement outputs
NEW SYSTEM OUTPUTS FROM PREVIOUS SYSTEM OUTPUTS/ STATES/ DERIVATIVES
From Old System State :    1                        Pitch Attitude    (theta-rigid)  (radians)                                      
From Old System State :    2                        Pitch Rate        ( q -rigid)    (rad/sec)                                      
From Old System State :    3                        Angle of attack   (alfa-rigid)   (radians)                                      
From Old System State :    4                        Change in Altitude (delta-h)      (feet)                                        
From Old System State :    5                        Change in Velocity (delta-V)      (ft/sec)                                      
From Old System Output:    6                        CG Acceleration along Z axis, (ft/sec^2)                                        
From Output Derivative:    4                        Change in Altitude, delta-h -(dot) (ft/sec)                    
From Old System State :    6                        Left Slosh Mass # 1 Displacem. Zs( 1)  (ft)                                     
From Old System State :    7                        Left Slosh Mass # 1 Displacem. Ys( 1)  (ft)                                     
From Old System State :   10                        Right Slosh Mass #2 Displacem. Zs( 2)  (ft)                                     
From Old System State :   11                        Right Slosh Mass #2 Displacem. Ys( 2)  (ft)                                     
------------------------------------------------------------------------------------------------------------------------
SYSTEM OF TRANSFER FUNCTIONS ...
Guidance (Altitude and Speed Control)
Continuous
TF. Block #  1 Integrator-1                                      Order of Numer, Denom=  0  1
Numer 0.00000     0.00012
Denom 1.00000     0.0
TF. Block #  2 Integrator-2                                      Order of Numer, Denom=  0  1
Numer 0.00000     0.1
Denom 1.00000     0.0
--------------------------------------------------------------------------------
Block #, from Input #, Gain
  1     1      1.00000
  2     3      1.00000
...........................
Outpt #, from Block #, Gain
  1     1      1.00000
  2     2      1.00000
...........................
Outpt #, from Input #, Gain
  1     1      0.0024
  1     2      0.012
  2     3      2.0
...........................
Definitions of Inputs  =   3
Vehicle Change in Altitude, h (ft)
Altitude Rate, h-dot (ft/sec)
Change in Velocity dV (ft/sec)
 
Definitions of Outputs =   2
Normal Accelerat Nz_Command to FCS
Command to the Speed Brake Actuator
------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle Landing, with Closed Pitch Flight Control Loop (Open Guidance)
! We are now going to close the flight control loop. The following system closes the 
! flight control loop by applying feedback from: [theta, q, and the Nz accelerometer] to
! the elevon actuator. The guidance loop is still open. The new system has the same outputs 
! as the open-loop plant and two inputs: (1) Nz_Command, (2) Speed_Brake Actuator Input
Titles of Systems to be Combined
Title 1 Automatic Landing of Unpowered Vehicle, Pitch Axis-2
Title 2 Control Surface Actuators 20/(s+20)
SYSTEM INPUTS TO SUBSYSTEM  2                                              To Elevon & Speed Brake Actuators
System Input  1 to Subsystem  2, Input  1, Gain=+0.007                     Nz_command
System Input  2 to Subsystem  2, Input  2, Gain= 1.0                       Speed_Brake
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                           from Vehicle Outputs
Via Matrix +I7
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  2                                           from Elevon & Speed Brake Actuators
System Output  8 from Subsystem  2, Output  1, Gain= 57.3                  Elevon (deg)
System Output  9 from Subsystem  2, Output  2, Gain= 57.3                  Speed Brk (deg)
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                    Feedback
Subsystem  1, Output  1 to Subsystem  1, Input  1, Gain= 0.02              Theta  +0.6
Subsystem  1, Output  2 to Subsystem  1, Input  1, Gain=+1.1               q      +0.6
Subsystem  1, Output  6 to Subsystem  1, Input  1, Gain=-0.007             Nz     -0.0075
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                    Actuator to Vehicle Feedback
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0               Elevon Loop
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0               Speed Brake Loop
..............................................................................
Definitions of Inputs  =   2
Nz_command
Speed_Brake Command

Definitions of Outputs =   9
Pitch Attitude    (theta-rigid)  (radians)                                      
Pitch Rate        ( q -rigid)    (rad/sec)                                      
Angle of attack   (alfa-rigid)   (radians)                                      
Change in Altitude (delta-h)      (feet)                                        
Change in Velocity (delta-V)      (ft/sec)                                      
CG Acceleration along Z axis, (ft/sec^2)                                        
Altitude derivative, delta-h-dot, (feet/sec)  
Elevon Deflection (deg)                
Speed Brake Deflection (deg)                
------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Vehicle Landing, with Closed Loop Pitch Guidance
! This System uses the previous system that has the flight control loop closed and closes
! the Guidance loop around it, that is, the Altitude Control and the Speed-Brake control
! loops via the Guidance control laws. The Guidance system reads the Vehicle change in 
! Altitude (dh), Altitude rate (h-dot), and change in Velocity (V), and it generates two 
! commands: (1) an N_z command that goes to the flight control system to change the 
! vehicle altitude, and (2) a speed-brake command that goes to the speed brake actuator.
Titles of Systems to be Combined
Title 1 Vehicle Landing, with Closed Pitch Flight Control Loop (Open Guidance)                     
Title 2 Guidance (Altitude and Speed Control)
SYSTEM INPUTS TO SUBSYSTEM  2                                          H and V Commands to Guidance
System Input  1 to Subsystem  2, Input  1, Gain=-1.0                   h_comm
System Input  2 to Subsystem  2, Input  3, Gain=-1.0                   V_comm
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                       Vehicle Outputs
Via Matrix +I9
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  2                                Vehicle to Guidance
Subsystem  1, Output  4 to Subsystem  2, Input  1, Gain= 1.0           h
Subsystem  1, Output  7 to Subsystem  2, Input  2, Gain= 1.0           h-dot
Subsystem  1, Output  5 to Subsystem  2, Input  3, Gain= 1.0           V
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                Guidance to FCS Inputs
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 70.0          Nz command
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 0.0174        Speed Brk command
..............................................................................
Definitions of Inputs  =   2
Altitude (h) command (h_comm) (ft)
Velocity (V) command (V_comm) (ft/sec)

Definitions of Outputs =   9
Pitch Attitude    (theta-rigid)  (radians)                                      
Pitch Rate        ( q -rigid)    (rad/sec)                                      
Angle of attack   (alfa-rigid)   (radians)                                      
Change in Altitude (delta-h)      (feet)                                        
Change in Velocity (delta-V)      (ft/sec)                                      
CG Acceleration along Z axis, (ft/sec^2)                                        
Altitude derivative, delta-h-dot, (feet/sec)  
Elevon Deflection (deg)                
Speed Brake Deflection (deg)                
------------------------------------------------------------------------------------------------------------------------
INTERCONNECTION OF SYSTEMS .....
Elevon Open-Loop System (Speed-Brake Closed)
! This system is used for stability analysis of the elevon loop in the 
! frequency domain (Nichols Charts)
Titles of Systems to be Combined
Title 1 Automatic Landing of Unpowered Vehicle, Pitch Axis-2
Title 2 Control Surface Actuators 20/(s+20)
Title 3 Guidance (Altitude and Speed Control)
SYSTEM INPUTS TO SUBSYSTEM  2                                              To Elevon Actuator
System Input  1 to Subsystem  2, Input  1, Gain= -1.0                      Elevon Actuator Input
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  1                                           from Vehicle
System Output  1 from Subsystem  1, Output  1, Gain=  0.02                 K-theta
System Output  1 from Subsystem  1, Output  2, Gain=  1.1                  K-q
System Output  1 from Subsystem  1, Output  6, Gain= -0.005                K-Kz
..............................................................................
SYSTEM OUTPUTS FROM SUBSYSTEM  3                                           from Guidance
System Output  1 from Subsystem  3, Output  1, Gain= 0.35                  Nz-command
..............................................................................
SUBSYSTEM NO  2 GOES TO SUBSYSTEM NO  1                                    Actuat to Vehicle
Subsystem  2, Output  1 to Subsystem  1, Input  1, Gain= 1.0               Elevon Act
Subsystem  2, Output  2 to Subsystem  1, Input  2, Gain= 1.0               Speed Brake Act
..............................................................................
SUBSYSTEM NO  1 GOES TO SUBSYSTEM NO  3                                    Vehi to Guidance
Subsystem  1, Output  4 to Subsystem  3, Input  1, Gain= 1.0               dh
Subsystem  1, Output  5 to Subsystem  3, Input  3, Gain= 1.0               dV
Subsystem  1, Output  7 to Subsystem  3, Input  2, Gain= 1.0               dh-dot
..............................................................................
SUBSYSTEM NO  3 GOES TO SUBSYSTEM NO  2                                    Speed-Brake to Act feedback
Subsystem  3, Output  2 to Subsystem  2, Input  2, Gain= 0.0174            Speed Brake Loop
..............................................................................
Definitions of Inputs  =   1
Elevon Actuator

Definitions of Outputs =   1
Flight Control to Actuator                                      
------------------------------------------------------------------------------------------------------------------------
                                     LATERAL AXES ANALYSIS
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Lateral Design Model                                                 
Automatic Landing of Unpowered Vehicle 
! Lateral LQR design system is extracted from the coupled system 
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   3   4 
Extract States :   1   2   5   6   8 
Extract Outputs:   1   2   5   6   8  
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Lateral Axes                                                 
Automatic Landing of Unpowered Vehicle 
! Lateral system is extracted from the coupled system 
TRUNCATE OR REORDER THE SYSTEM INPUTS, STATES, AND OUTPUTS
Extract Inputs :   3   4   5
Extract States :   1   2   5   6   8  11  12  13  14  15  16  17  18
Extract Outputs:   1   2   5   6   8  11  13
------------------------------------------------------------------------------------------------------------------------
CREATE A NEW SYSTEM FROM AN OLD SYSTEM... (Titles of the New and Old Systems)
Automatic Landing of Unpowered Vehicle, Lateral Axes-2                          
Automatic Landing of Unpowered Vehicle, Lateral Axes                                                 
! Another modified version of the above lateral system that includes 
! Slosh Mass displacement outputs
NEW SYSTEM OUTPUTS FROM PREVIOUS SYSTEM OUTPUTS/ STATES/ DERIVATIVES
From Old System Output:    1                        Roll Attitude  (phi-body) (radians)                                             
From Old System Output:    2                        Roll Rate      (p-body)   (rad/sec)                                             
From Old System Output:    3                        Yaw Attitude  (psi-body) (radians)                                             
From Old System Output:    4                        Yaw Rate      (r-body)   (rad/sec)                                             
From Old System Output:    5                        Angle of sideslip, beta, (radian)                                             
From Old System Output:    6                        Cross Range Velocity (Vcr) (ft/sec)                                             
From Old System Output:    7                        CG Acceleration along Y axis, (ft/sec^2)                                             
From Old System State :    6                        Left Slosh Mass # 1 Displacem. Zs( 1)  (ft)                                     
From Old System State :    7                        Left Slosh Mass # 1 Displacem. Ys( 1)  (ft)                                     
From Old System State :   10                        Right Slosh Mass #2 Displacem. Zs( 2)  (ft)                                     
From Old System State :   11                        Right Slosh Mass #2 Displacem. Ys( 2)  (ft)                                     
------------------------------------------------------------------------------------------------------------------------
END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-END-
